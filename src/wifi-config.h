#pragma once

#if defined (ESP32) || defined(ESP8266)

#ifdef ESP8266
#include <ESP8266WiFi.h>
#include <ESP8266WebServer.h>     // Local WebServer used to serve the configuration portal
ADC_MODE(ADC_VCC)                 // vcc read
#elif defined(ESP32)
#include <WiFi.h>
#include <esp_wifi.h>
#endif

#include "WiFiManager.h"          //https://github.com/tzapu/WiFiManager

extern WiFiManager wifiManager;

const char * THEME_STR[] PROGMEM = {
  "<br/><label for='theme'>Select theme</label><br><input type='radio' name='theme' value=0 checked> bright<br><input type='radio' name='theme' value=1> dark",
  "<br/><label for='theme'>Select theme</label><br><input type='radio' name='theme' value=0> bright<br><input type='radio' name='theme' value=1 checked> dark"
};

// convert favicon.ico to hex: http://tomeko.net/online_tools/file_to_hex.php?lang=en
const char tblFavicon[] PROGMEM = {0x00, 0x00, 0x01, 0x00, 0x01, 0x00, 0x10, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x68, 0x05,
                                   0x00, 0x00, 0x16, 0x00, 0x00, 0x00, 0x28, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x20, 0x00,
                                   0x00, 0x00, 0x01, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00,
                                   0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
                                   0x00, 0x00, 0x14, 0x14, 0x14, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
                                   0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
                                   0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
                                   0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
                                   0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
                                   0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
                                   0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
                                   0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
                                   0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
                                   0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
                                   0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
                                   0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
                                   0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
                                   0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
                                   0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
                                   0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
                                   0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
                                   0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
                                   0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
                                   0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
                                   0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
                                   0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
                                   0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
                                   0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
                                   0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
                                   0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
                                   0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
                                   0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
                                   0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
                                   0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
                                   0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
                                   0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
                                   0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
                                   0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
                                   0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
                                   0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
                                   0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
                                   0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
                                   0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
                                   0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
                                   0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
                                   0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
                                   0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
                                   0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
                                   0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
                                   0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
                                   0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
                                   0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
                                   0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
                                   0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
                                   0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
                                   0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
                                   0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
                                   0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
                                   0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
                                   0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
                                   0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
                                   0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
                                   0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
                                   0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
                                   0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
                                   0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
                                   0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
                                   0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
                                   0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
                                   0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
                                   0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
                                   0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
                                   0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
                                   0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
                                   0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
                                   0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
                                   0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
                                   0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
                                   0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
                                   0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
                                   0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
                                   0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
                                   0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
                                   0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x3F,
                                   0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0xEE, 0x77, 0x00, 0x00, 0xDE, 0x7B, 0x00, 0x00, 0xB6, 0x6D,
                                   0x00, 0x00, 0xAE, 0x75, 0x00, 0x00, 0x6A, 0x56, 0x00, 0x00, 0x56, 0x6A, 0x00, 0x00, 0x57, 0xEA,
                                   0x00, 0x00, 0x6B, 0xD6, 0x00, 0x00, 0xAF, 0xF5, 0x00, 0x00, 0xB7, 0xED, 0x00, 0x00, 0xDF, 0xFB,
                                   0x00, 0x00, 0xEF, 0xF7, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00
                                  };

void handleFavicon() {
  // bei 2 mal sendHeader ganz schechter Empfang von SD_WS_117_Bresser_7in1, bei einmal sendHeader OK egal welcher ???
  wifiManager.server->sendHeader(F("cache-control"), F("max-age=31536000, immutable")); // Cache-Control: max-age=31536000, immutable (1 Jahr)
  // wifiManager.server->sendHeader(F("x-content-type-options"), F("nosniff"));            // Response should include 'x-content-type-options' header.
  wifiManager.server->send_P(200, "image/x-icon", tblFavicon, sizeof(tblFavicon));
}

#define STATUS_COLS 14

static String jsonEsc(const String &in) {        // names are entered in the web configuration
  String o;
  for (uint16_t i = 0; i < in.length(); i++) {
    const char c = in[i];
    if (c == '"' || c == '\\') o += '\\';
    if ((uint8_t)c >= 0x20) o += c;
  }
  return o;
}

static String statusTrace() {                   // last pulses of radio 1
  String t;
  for (uint8_t i = 0; i < RADIO_TRACE_LEN; i++) {
    t += radioTrace[(radioTracePos + i) % RADIO_TRACE_LEN];
    t += ' ';
  }
  return t;
}

static void statusValues(uint8_t r, String v[STATUS_COLS]) {   // one row of the status table (HTML and /api/status)
  const uint8_t remRadio = curRadio;
  curRadio = r;
  v[0] = radioName(r);
  v[1] = String(RADIO_PORT_BASE + r);
#ifdef CMP_CC1101
  if (hasCC1101) {
    v[2] = String(ccFreq(), 3);
    v[3] = wmbus ? (wmbus_t ? F("WMBus T") : F("WMBus S")) : FPSTR(modTxt[cc1101::ccmode & 7]);
    const uint8_t raw = cc1101::getRSSI();     // current RSSI (noise floor if nothing is received)
    v[5] = String((raw >= 128 ? ((int)raw - 256) / 2 : raw / 2) - 74) + F(" dBm");
    v[13] = String(cc1101::getMARCSTATE() & 0x1F);
  } else {
    v[2] = '-';
    v[3] = ccDisabled ? F("aus") : F("-");
    v[5] = '-';
    v[13] = '-';
  }
#else
  v[2] = '-'; v[3] = F("ASK"); v[5] = '-'; v[13] = '-';
#endif
  v[4] = String(radioMsgCnt[r]);
  v[6] = serverClients[r].connected() ? F("verbunden") : F("-");
  v[7] = String(radioPulseCnt[r]);           // diagnostics: pin interrupts, FIFO fill, lost, polarity, spikes, missed edges
  v[8] = String(FiFos[r].count());
  v[9] = String(radioOvfCnt[r]);
  v[10] = String(radioSameSign[r]);
  v[11] = String(radioTrashCnt[r]);
  v[12] = String(radioLevelRep[r]);
  curRadio = remRadio;
}

void handleApiStatus() {                         // JSON for the live update of /custom
  webKeepOpen = true;
  String j;
  j.reserve(1024);
  j += F("{\"u\":"); j += getUptime();
  j += F(",\"c\":"); j += radioCronCnt;
  j += F(",\"l\":"); j += radioLoopRate;
  j += F(",\"w\":"); j += WiFi.RSSI();
  j += F(",\"h\":"); j += ESP.getFreeHeap();
  j += F(",\"t\":\""); j += statusTrace(); j += F("\",\"r\":{");
  bool first = true;
  for (uint8_t r = 0; r < NUM_RADIO; r++) {
    if (!radioUsed[r]) continue;
    String v[STATUS_COLS];
    statusValues(r, v);
    if (!first) j += ',';
    first = false;
    j += '"'; j += r; j += F("\":[");
    for (uint8_t k = 0; k < STATUS_COLS; k++) {
      if (k) j += ',';
      j += '"'; j += jsonEsc(v[k]); j += '"';
    }
    j += ']';
  }
  j += F("}}");
  wifiManager.server->sendHeader(F("Cache-Control"), F("no-store"));
  wifiManager.server->send(200, F("application/json"), j);
}

void handleSignal() {
  webKeepOpen = true;
  String page;
  page.reserve(4096);
  page += FPSTR(HTTP_HEAD_START);
  page.replace(FPSTR(T_v), F("SIGNAL-ESP"));
  page += FPSTR(HTTP_STYLE);
  page += FPSTR(HTTP_HEAD_END);
  if (EEPROM.read(EE_WM_THEME)) { // theme dark
    page.replace(FPSTR(T_c), F("invert")); // add class str for dark mode
  }
  page += F("<h3>SIGNAL-ESP</h3><hr><dl>");
  page += F("<dt>Firmware-Version</dt><dd>");
  page += PROGVERS;
  page += F("</dd>");
  page += F("<dt>SDK-Version</dt><dd>");
  page += ESP.getSdkVersion();
  page += F("</dd>");
#ifdef ESP32
  page += F("<dt>ESP32 Chip model</dt><dd>");
  page += ESP.getChipModel();
  page += F("</dd><dt>ESP32 Chip revision</dt><dd>");
  page += 'v';
  uint16_t rev = ESP.getChipRevision(); // It returns revision in the major * 100 + minor format.
  page += rev / 100;
  page += '.';
  page += rev - rev / 100 * 100;
  page += F("</dd>");
#endif
#ifdef ESP8266
  page += F("<dt>Supply voltage</dt><dd>");
  page += String(ESP.getVcc() / 1000.0, 2); // using a float and 2 decimal places
  page += F(" Volt</dd>");
#endif
  page += F("<dt>Letzter Neustart</dt><dd>");
  page += resetReason();
  page += F("</dd>");
  page += F("<dt>WiFi RSSI</dt><dd>");
  page += WiFi.RSSI();
  page += F(" dBm</dd>");
  page += F("</dl><table><tr><th>Modul</th><th>Port</th><th>Frequenz</th><th>Modus</th><th>Nachr.</th><th>RSSI</th><th>FHEM</th><th>Pulse</th><th>FIFO</th><th>Verlust</th><th>Vorz.</th><th>Kurz</th><th>Pegel</th><th>MARC</th></tr>");
  for (uint8_t r = 0; r < NUM_RADIO; r++) {
    if (!radioUsed[r]) continue;
    String v[STATUS_COLS];
    statusValues(r, v);
    page += F("<tr>");
    for (uint8_t k = 0; k < STATUS_COLS; k++) {
      page += F("<td id='s"); page += r; page += '_'; page += k; page += F("'>");
      page += v[k];
      page += F("</td>");
    }
    page += F("</tr>");
  }
  page += F("</table><small>Nachr. = empfangene Nachrichten seit Neustart, RSSI = aktueller Pegel, Pulse = Flanken an GDO2, FIFO = unverarbeitete Pulse, Verlust = Pulse verloren (FIFO voll), Vorz. = zwei Pulse gleicher Polarität hintereinander, MARC = CC1101-Zustand (13 = RX).<br>Kurz = Pulse unter 90 us verworfen, Pegel = gleicher Pin-Pegel in zwei Interrupts (Flanke verpasst).<br>Uptime <span id='su'>");
  page += getUptime();
  page += F("</span> s, Cronjob <span id='sc'>");
  page += radioCronCnt;
  page += F("</span>, loop/s <span id='sl'>");
  page += radioLoopRate;
  page += F("</span>, WiFi <span id='sw'>");
  page += WiFi.RSSI();
  page += F("</span> dBm <span id='so'></span><br>Letzte Pulse Modul 1 (us): <span id='st'>");
  page += statusTrace();
  page += F("</span></small><hr>");
  page += F("<script>function sdUpd(){fetch('/api/status').then(r=>r.json()).then(d=>{"
            "for(const r in d.r){d.r[r].forEach((v,k)=>{const e=document.getElementById('s'+r+'_'+k);if(e)e.textContent=v;});}"
            "['u','c','l','w','t'].forEach(k=>{const e=document.getElementById('s'+k);if(e)e.textContent=d[k];});"
            "document.getElementById('so').textContent='';}).catch(()=>{document.getElementById('so').textContent='(keine Verbindung)';});}"
            "setInterval(sdUpd,2500);</script>");
  page += F("<p/>Github <a href='https://github.com/RFD-FHEM/SIGNALDuino'>https://github.com/RFD-FHEM/SIGNALDuino</a>");
  page += FPSTR(HTTP_END);
  wifiManager.server->send(200, FPSTR(HTTP_HEAD_CT), page);
}

void bindServerCallback() {
#ifdef ESP32
  webOtaBind();                                          // before WiFiManager registers its own /u
#endif
  wifiManager.server->on("/custom", handleSignal);
  wifiManager.server->on("/api/status", handleApiStatus);
  wifiManager.server->on("/sd", handleConfig);
  if (!wifiManager.getConfigPortalActive()) {           // connected: start page = SIGNAL-ESP config, AP mode: WiFiManager
    wifiManager.server->on("/", handleConfig);
  }
  wifiManager.server->on("/favicon.ico", handleFavicon);
}

void configModeCallback(WiFiManager *myWiFiManager) {
  Serial.print(F("Starting AP with SSID: "));
  // if you used auto generated SSID, print it
  Serial.print(myWiFiManager->getConfigPortalSSID());
  if (strlen(WM_AP_PASSWORD) > 0) {
    Serial.print(F(" and password: "));
    Serial.print(F(WM_AP_PASSWORD));
  }
  Serial.println();
  Serial.print(F("Please open "));
  Serial.print(WiFi.softAPIP());
  Serial.println(F(" in your browser and configure WiFi."));
}

void saveConfigCallback() {
  loopWdtResume();                                   // connected, see setPreSaveConfigCallback
  DBG_PRINTLN("Should save config");
  IPAddress ip(0, 0, 0, 0);
  IPAddress gateway(0, 0, 0, 0);
  IPAddress subnet(0, 0, 0, 0);
  if (wifiManager.server->arg(FPSTR(S_ip)) != "") { // got static IP
    // Serial.println("saveConfigCallback");
    ip = WiFi.localIP();
    gateway = WiFi.gatewayIP();
    subnet = WiFi.subnetMask();
  } else { // DHCP
    DBG_PRINTLN("reset wifi static settings");
    WiFi.config(ip, gateway, subnet); // reset static ip, gw, sn
    wifiManager.disconnect();
    wifiManager.setSTAStaticIPConfig(ip, gateway, subnet); // wifimanager reset static ip, gw, sn
    loopWdtPause();                                  // autoConnect blocks (connect timeout, config portal)
    bool res = wifiManager.autoConnect("AutoConnectAP", WM_AP_PASSWORD); // same AP password as first start ("" = open)
    loopWdtResume();
    if (!res) {
      Serial.println(F("Failed to connect or hit timeout"));
      // ESP.restart();
    } else {
      wifiManager.setConfigPortalBlocking(false);
      wifiManager.startWebPortal();
    }
  }
#ifdef DEBUG
  Serial.print("IP: ");
  Serial.println(WiFi.localIP()); // WiFi.localIP() returns the local IP address assigned to the device as an IPAddress.
  Serial.print("GW: ");
  Serial.println(WiFi.gatewayIP());
  Serial.print("NM: ");
  Serial.println(WiFi.subnetMask());
#endif
  EEPROM_write_ipaddress(EE_IP, ip);
  EEPROM_write_ipaddress(EE_GW, gateway);
  EEPROM_write_ipaddress(EE_SNM, subnet);
}

String getParam(String name) {
  //read parameter from server, for customhmtl input
  String value;
  if (wifiManager.server->hasArg(name)) {
    value = wifiManager.server->arg(name);
  }
  return value;
}

void saveParamCallback() {
  loopWdtResume();                                   // params saved, see setPreSaveConfigCallback
  //Serial.println("[CALLBACK] saveParamCallback fired");
  //Serial.println("PARAM theme = " + getParam("theme"));
  if (getParam("theme") == "1") {
    wifiManager.setClass("invert"); // set dark theme
    new (&custom_field) WiFiManagerParameter(THEME_STR[1]);
    EEPROM.write(EE_WM_THEME, 1);
  } else {
    wifiManager.setClass("");
    new (&custom_field) WiFiManagerParameter(THEME_STR[0]);
    EEPROM.write(EE_WM_THEME, 0);
  }
  EEPROM.commit();
}

void resetwifi() {
  wifiManager.resetSettings();
#ifdef esp8266
  ESP.reset();
#elif defined(ESP32)
  ESP.restart();
#endif
}

#endif
